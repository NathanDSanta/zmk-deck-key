## dts/bindings/behaviors/zmk,behavior-deck-key.yaml
```yaml
description: Send a deck key index over Raw HID
compatible: "zmk,behavior-deck-key"
binding-cells: [key-index]
```
